DESCRIPTION = "Image with OpenUxAS"

#IMAGE_FEATURES += "ssh-server-openssh"

LICENSE = "USAFOSA"

inherit core-image

IMAGE_INSTALL += "openuxas"

