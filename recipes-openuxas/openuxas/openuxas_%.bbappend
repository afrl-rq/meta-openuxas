SRCREV = "4f1063557d189ac362eba0cdf2de5d8ef4af0a93"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-generated-LMCP-sources.patch"

